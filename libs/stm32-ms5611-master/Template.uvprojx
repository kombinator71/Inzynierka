# Keil uVision project Template.uvprojx, settings and files
target Template (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\Lib\inc;.\USR;.\System;.\System\delay;.\System\sys;.\System\usart;.\ASM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USR
    ./USR/: main.c mydefine.c ms5611.c
  group LIB
    ./Lib/SRC/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_usart.c
    ./LIB/src/: stm32f10x_spi.c
  group SYSTEM
    ./System/: system_stm32f10x.c
    ./System/delay/: delay.c
    ./System/sys/: sys.c
  group CORE
    ./ASM/: startup_stm32f10x_hd.s core_cm3.c
